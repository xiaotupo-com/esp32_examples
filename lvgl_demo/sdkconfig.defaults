## lvgl_demo/sdkconfig.defaults
```kconfig
CONFIG_LVGL_SUPPORT=y
CONFIG_LVGL_VERSION_8=y
CONFIG_LVGL_TICK_PERIOD_MS=1
CONFIG_LVGL_DISP_BUF_SIZE=32768  # 根据 RAM 调整
```
